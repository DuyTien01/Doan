# Keil uVision project DoAnTotNghiep.uvprojx, settings and files
target DoAnTotNghiep (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: DoAnTotNghiep +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;                                                                                                                ../Drivers/STM32F1xx_HAL_Driver/Inc;                                                                                                                ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;                                                                                                                ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;                                                                                                                ../Drivers/CMSIS/Include;                                                                                                                ..\DELAY_TIMER\inc;                                                                                                                ..\DS18B20;                                                                                                                ..\I2C_LCD;                                                                                                                D:\Programming_Microcontroler\Lap Trinh STM\STM32F103C8T6\STM32_Device_Lib-master\Device Lib\Inc;                                                                                                                D:\Programming_Microcontroler\Lap Trinh STM\STM32F103C8T6\STM32_Device_Lib-master\DELAY_TIMER\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: flash.c main.c stm32f1xx_it.c stm32f1xx_hal_msp.c
    ../Core/Inc/: flash.h define.h
    ../DELAY_TIMER/src/: delay_timer.c
    ../DS18B20/: DS18B20.c
    ../I2C_LCD/: CLCD_I2C.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_i2c.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
software components: CMSIS:CORE 4.3.0
